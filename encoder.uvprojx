# Keil uVision project encoder.uvprojx, settings and files
target STM32F411RETx (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: encoder
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App
    ./: main.c
  group New Group
    ./: delay.c delay.h GLCD_ST7735.c GLCD_ST7735.h SPI.c SPI.h SysClockConfig.c SysClockConfig.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
